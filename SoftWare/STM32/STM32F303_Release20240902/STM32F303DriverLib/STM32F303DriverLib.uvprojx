# Keil uVision project STM32F303DriverLib.uvprojx, settings and files
target STM32F303DriverLib (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303RC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303DriverLib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\inc;.\reg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group inc
    ./inc/: drv_comp.h drv_cpu.h drv_dac.h drv_dbgmcu.h drv_delay.h drv_dma.h drv_exti.h drv_flash.h drv_gpio.h drv_iwdg.h drv_nvic.h drv_opamp.h drv_rcc.h drv_syscfg.h drv_timer.h drv_uart.h
  group src
    ./src/: drv_comp.c drv_cpu.c drv_dac.c drv_dbgmcu.c drv_delay.c drv_dma.c drv_exti.c drv_flash.c drv_gpio.c drv_iwdg.c drv_nvic.c drv_opamp.c drv_rcc.c drv_syscfg.c drv_timer.c drv_uart.c
  group reg
    ./reg/: reg_stm32f303_address.h reg_stm32f303_comp.h reg_stm32f303_dbg.h reg_stm32f303_dma.h reg_stm32f303_exti.h reg_stm32f303_flash.h reg_stm32f303_gpio.h reg_stm32f303_iwdg.h reg_stm32f303_nvic.h reg_stm32f303_opamp.h reg_stm32f303_rcc.h reg_stm32f303_spi.h reg_stm32f303_syscfg.h reg_stm32f303_timer.h reg_stm32f303_uart.h typedefine.h
