# Keil uVision project firmware_wm_00_hal.uvprojx, settings and files
target hal (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303RC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware_wm_00_hal (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\STM32F303DriverLib\reg;..\STM32F303DriverLib\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./src/: hal_clock.c hal_delay.c hal_gpio.c hal_timer.c hal_uart.c hal_pd_pulse.c
  group lib
    ../STM32F303DriverLib/Objects/: STM32F303DriverLib.lib
  group inc
    ./inc/: hal_clock.h hal_delay.h hal_gpio.h hal_irq_priority.h hal_led_flash.h hal_timer.h hal_uart.h hal_pd_pulse.h
